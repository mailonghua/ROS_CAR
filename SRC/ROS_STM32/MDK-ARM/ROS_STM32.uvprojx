# Keil uVision project ROS_STM32.uvprojx, settings and files
target ROS_STM32 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ROS_STM32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,STM32F103xC
  c include: ../Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;    ../Drivers/CMSIS/Include;    ..\Devices\LCD096;    ..\Devices\MPU6050;    ..\Devices\MPU6050\eMPL;    ..\Devices\Embedded_MotionDriver_5.1\core\driver\eMPL;    ..\Devices\MPU6050\Inc;    ..\Devices\Delay;    ..\Devices\Software_PID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f10x_hd.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Devices
    ../Devices/MPU6050/Src/: mpu6050.c
    ../Devices/Embedded_MotionDriver_5.1/core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Devices/Delay/: ax_delay.c
    ../Devices/Motor/: motor_drive.c
    ../Devices/ADC/: vin_adc.c
    ../Devices/Debug/: debug_uart.c
    ../Devices/Motor_Encode/: motor_encode.c
    ../Devices/MainLoop/: main_loop.c
    ../Devices/Kinematics/: Kinematics.c
    ../Devices/PID/: motor_pid.c
    ../Devices/LCD096/: ssd1306.c fonts.c
    ../Devices/Communication/: Communication_Serial.c
  group Software/PID
    ../Devices/Software_PID/: protocol.c
  group ReadMe
    ../: ReadMe.txt
software components: CMSIS:CORE 3.40.0
